<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>STM8L Library</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\..\Library\STM8L15x_StdPeriph_Driver\inc\stm8l15x.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Library\STM8L15x_StdPeriph_Driver\inc\stm8l15x_clk.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Library\STM8L15x_StdPeriph_Driver\inc\stm8l15x_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Library\STM8L15x_StdPeriph_Driver\inc\stm8l15x_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Library\STM8L15x_StdPeriph_Driver\inc\stm8l15x_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Library\STM8L15x_StdPeriph_Driver\inc\stm8l15x_spi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Library\STM8L15x_StdPeriph_Driver\inc\stm8l15x_tim4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Library\STM8L15x_StdPeriph_Driver\inc\stm8l15x_wwdg.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\..\Library\STM8L15x_StdPeriph_Driver\src\stm8l15x_clk.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Library\STM8L15x_StdPeriph_Driver\src\stm8l15x_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Library\STM8L15x_StdPeriph_Driver\src\stm8l15x_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Library\STM8L15x_StdPeriph_Driver\src\stm8l15x_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Library\STM8L15x_StdPeriph_Driver\src\stm8l15x_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Library\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Library\STM8L15x_StdPeriph_Driver\src\stm8l15x_wwdg.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\inc\_global.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\button.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\delay.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\MyMessage.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\PPTCtrl_Protocol.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\ProtocolParser.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\rf24l01.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\stm8l15x_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\stm8l15x_it.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\timer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\xliNodeConfig.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\src\button.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\delay.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\ProtocolParser.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\rf24l01.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\stm8l15x_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\timer.c</name>
      </file>
    </group>
  </group>
</project>


